# Keil uVision project R3.uvprojx, settings and files
target STM32f446RE (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: R3 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\R3;.\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group program
    ./: main.cpp frsky_sport.cpp frsky_sbus.cpp geometry.cpp imu.cpp telemetry.cpp gps.cpp utils.cpp pid.cpp ahrs_Mahony.cpp
  group drivers
    ./drivers/: i2c_sensor.cpp l3g4200d.cpp lis3mdl.cpp lis331dlh.cpp
software components: CMSIS:CORE 5.0.0, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:CRC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:USART 1.6.0, Device:Startup 2.6.0
